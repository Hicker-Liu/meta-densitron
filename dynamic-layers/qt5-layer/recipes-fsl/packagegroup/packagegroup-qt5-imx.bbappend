# add common packages also for not X11 builds
QT5_IMAGE_INSTALL_append = " \
	qtquickcontrols \
	qtquickcontrols2 \
	qtquicktimeline \
"

